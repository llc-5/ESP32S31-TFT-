#include "font.h"
#include "ili9341.h"

/* ============================================================================
 * 8x16 点阵字库
 *
 * 每个字符 16 个字节，每个字节是竖直方向的 8 个像素，最高位（0x80）在左。
 * 例：0x7F = 0111 1111，画出来是左边 7 个点亮、最右边 1 个点灭。
 *
 * A~Z 是逐字搬自你 STM32 那边跑通的 04_RealHardware/ili9341.c，不要改 ——
 * 那些字形你在实物屏上验证过。
 * 0~9 是同一套字库里配套的数字，笔画粗细、高度跟 A~Z 一致。
 * ========================================================================== */

/* 数字 0 ~ 9 */
static const unsigned char FONT_09[10][16] = {
    {0x00,0x3C,0x66,0x63,0x63,0x63,0x6F,0x6F,0x63,0x63,0x63,0x63,0x63,0x66,0x3C,0x00}, /* 0 */
    {0x00,0x0C,0x1C,0x3C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x3F,0x00}, /* 1 */
    {0x00,0x3C,0x66,0x63,0x03,0x03,0x06,0x0C,0x18,0x30,0x60,0x60,0x60,0x63,0x7F,0x00}, /* 2 */
    {0x00,0x3C,0x66,0x63,0x03,0x03,0x1E,0x06,0x03,0x03,0x03,0x03,0x63,0x66,0x3C,0x00}, /* 3 */
    {0x00,0x06,0x0E,0x1E,0x36,0x66,0x66,0x66,0x7F,0x06,0x06,0x06,0x06,0x06,0x0F,0x00}, /* 4 */
    {0x00,0x7F,0x60,0x60,0x60,0x7C,0x66,0x03,0x03,0x03,0x03,0x03,0x63,0x66,0x3C,0x00}, /* 5 */
    {0x00,0x1E,0x30,0x60,0x60,0x60,0x7C,0x66,0x63,0x63,0x63,0x63,0x63,0x66,0x3C,0x00}, /* 6 */
    {0x00,0x7F,0x63,0x03,0x06,0x06,0x0C,0x0C,0x0C,0x18,0x18,0x18,0x18,0x18,0x18,0x00}, /* 7 */
    {0x00,0x3C,0x66,0x63,0x63,0x66,0x3C,0x66,0x63,0x63,0x63,0x63,0x63,0x66,0x3C,0x00}, /* 8 */
    {0x00,0x3C,0x66,0x63,0x63,0x63,0x63,0x63,0x3F,0x03,0x03,0x03,0x03,0x06,0x3C,0x00}, /* 9 */
};

/* 字母 A ~ Z（原封不动搬自 STM32 工程） */
static const unsigned char FONT_AZ[26][16] = {
    {0x00,0x0C,0x0C,0x0C,0x1C,0x1E,0x1E,0x1E,0x36,0x3E,0x36,0x33,0x63,0x63,0x63,0x00}, /* A */
    {0x00,0x7C,0x6C,0x66,0x66,0x66,0x6C,0x7C,0x6C,0x66,0x66,0x66,0x66,0x6C,0x7C,0x00}, /* B */
    {0x00,0x3C,0x36,0x63,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x63,0x36,0x3C,0x00}, /* C */
    {0x00,0x7C,0x6C,0x66,0x66,0x66,0x66,0x66,0x66,0x66,0x66,0x66,0x66,0x66,0x7C,0x00}, /* D */
    {0x00,0x7F,0x60,0x60,0x60,0x60,0x60,0x7E,0x60,0x60,0x60,0x60,0x60,0x60,0x7F,0x00}, /* E */
    {0x00,0x7F,0x60,0x60,0x60,0x60,0x60,0x7E,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x00}, /* F */
    {0x00,0x3C,0x36,0x66,0x63,0x60,0x60,0x60,0x60,0x6F,0x63,0x63,0x63,0x33,0x3F,0x00}, /* G */
    {0x00,0x63,0x63,0x63,0x63,0x63,0x63,0x7F,0x63,0x63,0x63,0x63,0x63,0x63,0x63,0x00}, /* H */
    {0x00,0x7F,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x7F,0x00}, /* I */
    {0x00,0x3F,0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x06,0x06,0x3C,0x00}, /* J */
    {0x00,0x66,0x6C,0x6C,0x78,0x70,0x70,0x60,0x78,0x6C,0x66,0x66,0x66,0x63,0x63,0x00}, /* K */
    {0x00,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x7F,0x00}, /* L */
    {0x00,0x66,0x66,0x7E,0x7E,0x7E,0x7E,0x7E,0x63,0x63,0x63,0x63,0x63,0x63,0x63,0x00}, /* M */
    {0x00,0x63,0x63,0x73,0x73,0x7B,0x7B,0x7B,0x6F,0x6F,0x6F,0x67,0x67,0x63,0x63,0x00}, /* N */
    {0x00,0x3C,0x66,0x63,0x63,0x63,0x63,0x63,0x63,0x63,0x63,0x63,0x63,0x36,0x3C,0x00}, /* O */
    {0x00,0x7C,0x6C,0x66,0x66,0x66,0x6C,0x7C,0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x00}, /* P */
    {0x00,0x3C,0x66,0x63,0x63,0x63,0x63,0x63,0x63,0x63,0x63,0x6F,0x67,0x36,0x3F,0x00}, /* Q */
    {0x00,0x7C,0x6C,0x66,0x66,0x66,0x6C,0x7C,0x70,0x78,0x78,0x6C,0x66,0x66,0x63,0x00}, /* R */
    {0x00,0x3C,0x36,0x63,0x60,0x30,0x30,0x1E,0x06,0x03,0x03,0x63,0x66,0x36,0x3C,0x00}, /* S */
    {0x00,0x7F,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x00}, /* T */
    {0x00,0x63,0x63,0x63,0x63,0x63,0x63,0x63,0x63,0x63,0x63,0x63,0x63,0x66,0x3E,0x00}, /* U */
    {0x00,0x63,0x63,0x63,0x63,0x33,0x33,0x36,0x36,0x36,0x36,0x1E,0x1E,0x1E,0x0C,0x00}, /* V */
    {0x00,0x61,0x61,0x61,0x61,0x61,0x61,0x7F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x00}, /* W */
    {0x00,0x63,0x63,0x36,0x36,0x1C,0x1C,0x1C,0x1C,0x1C,0x1C,0x36,0x36,0x63,0x63,0x00}, /* X */
    {0x00,0x63,0x63,0x36,0x36,0x3C,0x1C,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x00}, /* Y */
    {0x00,0x7F,0x03,0x06,0x06,0x0C,0x0C,0x0C,0x18,0x18,0x18,0x30,0x30,0x60,0x7F,0x00}, /* Z */
};

/* 取字模：数字、字母各自查表，其它一律按空格（全 0）处理 */
static const unsigned char *glyph_of(char c)
{
    static const unsigned char BLANK[16] = {0};

    if (c >= '0' && c <= '9') {
        return FONT_09[(uint8_t)(c - '0')];
    }
    if (c >= 'A' && c <= 'Z') {
        return FONT_AZ[(uint8_t)(c - 'A')];
    }
    if (c >= 'a' && c <= 'z') {          /* 小写自动当大写画 */
        return FONT_AZ[(uint8_t)(c - 'a')];
    }
    return BLANK;
}

static uint8_t s_row[LCD_WIDTH * 2];

void font_draw_char(uint16_t x, uint16_t y, char c,
                    uint16_t fg, uint16_t bg, uint8_t scale)
{
    const unsigned char *g = glyph_of(c);
    uint8_t  row, col, k;
    uint16_t w = (uint16_t)(FONT_W * scale);

    if (scale == 0) {
        scale = 1;
        w = FONT_W;
    }
    if (x >= LCD_WIDTH || y >= LCD_HEIGHT) {
        return;
    }
    if (x + w > LCD_WIDTH) {
        w = (uint16_t)(LCD_WIDTH - x);
    }

    for (row = 0; row < FONT_H; row++) {
        uint32_t o = 0;

        /* 把这一行 8 个点按倍率横向展开成 RGB565 字节流 */
        for (col = 0; col < FONT_W; col++) {
            uint16_t color = (g[row] & (0x80 >> col)) ? fg : bg;
            uint8_t  hi = (uint8_t)(color >> 8);
            uint8_t  lo = (uint8_t)(color & 0xFF);
            uint8_t  rep;
            for (rep = 0; rep < scale; rep++) {
                if (o + 2 > sizeof(s_row)) {
                    break;
                }
                s_row[o++] = hi;
                s_row[o++] = lo;
            }
        }

        /* 纵向重复 scale 次 */
        for (k = 0; k < scale; k++) {
            uint16_t dy = (uint16_t)(y + row * scale + k);
            if (dy >= LCD_HEIGHT) {
                return;
            }
            ili9341_draw_row(x, dy, w, s_row);
        }
    }
}

void font_draw_text(uint16_t x, uint16_t y, const char *s,
                    uint16_t fg, uint16_t bg, uint8_t scale)
{
    uint16_t cx = x;

    if (scale == 0) {
        scale = 1;
    }
    while (*s) {
        font_draw_char(cx, y, *s, fg, bg, scale);
        cx = (uint16_t)(cx + FONT_W * scale + scale);   /* 字间距 = scale 像素 */
        s++;
    }
}

uint16_t font_text_width(const char *s, uint8_t scale)
{
    uint16_t n = 0;

    if (scale == 0) {
        scale = 1;
    }
    while (*s) {
        n = (uint16_t)(n + FONT_W * scale + scale);
        s++;
    }
    return n ? (uint16_t)(n - scale) : 0;   /* 去掉最后一个字后面的间距 */
}
